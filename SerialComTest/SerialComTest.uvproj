# Keil uVision project SerialComTest.uvproj, settings and files
target Sim (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USARTTest
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\inc;.\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./src/: main.c
  group CMSIS
    ../CMSIS/: setup_stm32f10x.c startup_stm32f10x_md.s
  group doc
    ./: readme.txt
  group common
    ../Common/: serial.c armsis.c
target RAM (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: SerialComTest +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD VECT_TAB_SRAM
  c include: .\inc;..\CMSIS;..\Common
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
target Flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: SerialComTest +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\inc;..\CMSIS;..\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
