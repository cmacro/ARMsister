# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: system_stm32f10x.c startup_stm32f10x_md.s
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
