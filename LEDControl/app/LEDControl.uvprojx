# Keil uVision project LEDControl.uvprojx, settings and files
target LEDControl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LEDControl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB
  c include: ../CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../src/: Main.c
  group CMSIS
    ../src/: system_stm32f1xx.c
    ../CMSIS/: startup_stm32f103xb.s stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
  group comm
    ../src/: armsis.c armsis.h serial.c serial.h
