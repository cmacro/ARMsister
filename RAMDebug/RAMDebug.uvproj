# Keil uVision project RAMDebug.uvproj, settings and files
target RAMDebug (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RAMDebug +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\inc;.\CMSIS
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
  group user
    ./src/: armsis.c main.c
  group CMSIS
    ./CMSIS/: setup_stm32f10x.c startup_stm32f10x_md.s
  group doc
    ./: readme.txt
